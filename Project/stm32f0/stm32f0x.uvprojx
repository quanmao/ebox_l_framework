# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F030x6
  c include: ..\..\FrameWork\stm32f0\ST\CMSIS\Core\Include;..\..\FrameWork\stm32f0\ST\CMSIS\Device\ST\STM32F0xx\Include;..\..\FrameWork\stm32f0\ST\STM32F0xx_HAL_Driver\Inc;..\..\User;..\..\User\stm32f030f4;..\..\FrameWork\common;..\..\FrameWork\stm32f0\eBox;..\..\FrameWork\stm32f0\eBox\mcu;..\..\..\my-lib\drive\ebox;..\..\..\my-lib\drive\utility\LCDMenuLib2-2.2.7\src;..\..\..\my-lib\drive\utility\filter
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group start_code
    ../../FrameWork/stm32f0/ST/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x6.s startup_stm32f072xb.s startup_stm32f030x8.s
  group CMSIS
    ../../FrameWork/stm32f0/ST/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group libraries_LL
    ../../FrameWork/stm32f0/ST/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_utils.c stm32f0xx_ll_rcc.c stm32f0xx_ll_gpio.c
  group ebox_core
    ../../FrameWork/common/: ebox_print.cpp vector.h WString.cpp itoa.c LinkedList.h ebox_mem.c sort.cpp print.cpp keyboard.cpp
  group ebox_mcu
    ../../FrameWork/stm32f0/eBox/: ebox_gpio.cpp ebox_base.cpp ebox_uart.cpp ebox_exti.cpp ebox_spi.cpp ebox_adc.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_timer.cpp ebox_timer_it.cpp ebox_pwm.cpp ebox_in_capture.cpp ebox_i2c.cpp ebox_rtc.cpp ebox_power.cpp ebox_gpios.cpp
    ../../FrameWork/common/: ebox_softi2c.cpp ebox_softspi.cpp
  group user
    ../../User/stm32f030f4/: ebox_config.h bsp_ebox.cpp mcu_config.h
    ../../User/: main.cpp
  group example
    ../../example/: uart.cpp exit.cpp gpios.cpp adc.cpp wdg.cpp flash.cpp timer1.cpp pwm.cpp inCapture_sample.cpp rtc_calendar.cpp I2C_search address.cpp vector_example.cpp List_Class.cpp List_SimpleInteger.cpp List_Sort.cpp memDynamic.cpp printExample.cpp power_sleep.cpp power_rtc wakeup.cpp key.cpp
  group driver
    ../../../my-lib/drive/ebox/AD9833/: AD9833-example.cpp AD9833.cpp
    ../../../my-lib/drive/ebox/: BH1750.cpp BH1750.h BH1750-example.cpp LiquidCrystal_I2C.cpp LiquidCrystal-example.cpp LTC1446.cpp LTC1446-example.cpp
    ../../../my-lib/drive/ebox/MAX31865/: MAX31865.cpp Max31865-example.cpp
    ../../../my-lib/drive/ebox/AD9954/: AD9954.cpp AD9954.h AD9954-example.cpp
    ../../../my-lib/drive/ebox/CS5522/: CS5522.cpp CS5522-example.cpp
  group util
    ../../../my-lib/drive/utility/LINEAR/: Linear.cpp LinearExample.cpp LinearPiecewise.cpp LinearPiecewiseExample.cpp
    ../../../my-lib/drive/utility/filter/: filter.cpp filterExample.cpp
  group menu
    ../../../my-lib/drive/utility/ArduinoMenu/src/: baseMacros.h items.cpp items.h itemsTemplates.hpp macros.h menu.cpp menu.h menuBase.cpp menuBase.h menuDefs.h menuIo.cpp menuIo.h nav.cpp nav.h shadows.h
    ../../../my-lib/drive/utility/ArduinoMenu/src/menuIO/: serialOut.cpp
  group menu1
    ../../../my-lib/drive/utility/LCDMenuLib2-2.2.7/src/: LCDMenuLib2.cpp LCDMenuLib2_menu.cpp
    ../../../my-lib/drive/utility/LCDMenuLib2-2.2.7/examples/00_beginners/LCDML_000_serialMonitor/: LCDML_example_serialMonitor.cpp
    ../../../my-lib/drive/utility/LCDMenuLib2-2.2.7/examples/02_functionality/LCDML_020_filelist/: LCDML_020_filelist.cpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
