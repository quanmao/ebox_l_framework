# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F103xB
  c include: ..\..\FrameWork\stm32f1\ST\CMSIS\Core\Include;..\..\FrameWork\stm32f1\ST\CMSIS\Device\ST\STM32F1xx\Include;..\..\FrameWork\stm32f1\ST\STM32F1xx_HAL_Driver\Inc;..\..\User\spark_f1;..\..\FrameWork\stm32f1\eBox;..\..\FrameWork\stm32f1\eBox\mcu;..\..\FrameWork\common;..\..\..\my-lib\drive\ebox;..\..\..\my-lib\drive\utility\LCDMenuLib2-2.2.7\src;..\..\..\my-lib\drive\utility\SFUD\sfud\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../../FrameWork/stm32f1/ST/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103x6.s startup_stm32f103xb.s startup_stm32f103xe.s
  group CMSIS
    ../../FrameWork/stm32f1/ST/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group libraries_ll
    ../../FrameWork/stm32f1/ST/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_gpio.c stm32f1xx_ll_tim.c
  group ebox_core
    ../../FrameWork/common/: ebox_print.cpp
  group ebox_mcu
    ../../FrameWork/common/: ebox_object.cpp ebox_gpios.cpp ebox_softi2c.cpp ebox_softspi.cpp
    ../../FrameWork/stm32f1/eBox/: ebox_base.cpp ebox_gpio.cpp ebox_uart.cpp ebox_exti.cpp ebox_spi.cpp ebox_adc.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_timer.cpp ebox_timer_it.cpp ebox_pwm.cpp ebox_in_capture.cpp ebox_i2c.cpp ebox_rtc.cpp
  group user
    ../../User/: main.cpp
    ../../User/spark_f1/: bsp_ebox.cpp ebox_config.h mcu_config.h
  group example
    ../../example/: uart.cpp exit.cpp gpios.cpp adc.cpp wdg.cpp flash.cpp pwm.cpp timer1.cpp inCapture_sample.cpp I2C_search address.cpp rtc_calendar.cpp temp.cpp
  group driver
    ../../../my-lib/drive/ebox/: LiquidCrystal_I2C.cpp LiquidCrystal-example.cpp BH1750.cpp BH1750-example.cpp LTC1446.cpp LTC1446-example.cpp TM770X.cpp TM770X-example.cpp TM7707.cpp TM7707-example.cpp
    ../../../my-lib/drive/ebox/CS5522/: CS5522.cpp CS5522-example.cpp
    ../../../my-lib/drive/ebox/MAX31865/: MAX31865.cpp Max31865-example.cpp
  group menu
    ../../../my-lib/drive/utility/LCDMenuLib2-2.2.7/src/: LCDMenuLib2.cpp LCDMenuLib2_menu.cpp
    ../../../my-lib/drive/utility/LCDMenuLib2-2.2.7/examples/00_beginners/LCDML_000_serialMonitor/: LCDML_example_serialMonitor.cpp
  group file
    ../../../my-lib/drive/utility/storage/littlefs-master/: lfs.c lfs_util.c littleFs_example.cpp
  group SPF
    ../../../my-lib/drive/utility/SFUD/ebox/: ebox_sfud_port.cpp
    ../../../my-lib/drive/utility/SFUD/sfud/src/: sfud.c sfud_sfdp.c
    ../../../my-lib/drive/utility/SFUD/: sfud_sample.cpp
