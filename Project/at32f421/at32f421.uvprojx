# Keil uVision project at32f421.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421F8P7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\FrameWork\at32f421\AT\cmsis\cm4\core_support;..\..\FrameWork\at32f421\AT\cmsis\cm4\device_support;..\..\FrameWork\at32f421\AT\drivers\inc;..\..\User;..\..\User\at32f421f8P7;..\..\FrameWork\common;..\..\FrameWork\at32f421\eBox;..\..\FrameWork\at32f421\eBox\mcu;..\..\..\my-lib\drive\ebox;..\..\..\my-lib\drive\utility\LCDMenuLib2-2.2.7\src;..\..\..\my-lib\drive\utility\filter
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group start_code
    ../../FrameWork/at32f421/AT/cmsis/cm4/device_support/startup/mdk/: startup_at32f421.s
  group CMSIS
    ../../FrameWork/at32f421/AT/cmsis/cm4/device_support/: system_at32f421.c
  group libraries
    ../../FrameWork/at32f421/AT/drivers/src/: at32f421_crm.c at32f421_gpio.c at32f421_misc.c at32f421_usart.c
  group ebox_core
    ../../FrameWork/common/: ebox_print.cpp vector.h WString.cpp itoa.c LinkedList.h ebox_mem.c sort.cpp print.cpp keyboard.cpp
  group ebox_mcu
    ../../FrameWork/at32f421/eBox/: ebox_base.cpp ebox_gpio.cpp ebox_uart.cpp ebox_gpios.cpp
  group user
    ../../User/: main.cpp
    ../../User/at32f421f8P7/: ebox_config.h mcu_config.h bsp_ebox.cpp
  group example
    ../../example/: uart.cpp exit.cpp gpios.cpp adc.cpp wdg.cpp flash.cpp timer1.cpp pwm.cpp inCapture_sample.cpp rtc_calendar.cpp I2C_search address.cpp vector_example.cpp List_Class.cpp List_SimpleInteger.cpp List_Sort.cpp memDynamic.cpp printExample.cpp power_sleep.cpp power_rtc wakeup.cpp key.cpp gpio.cpp
  group util
    ../../../my-lib/drive/utility/LINEAR/: Linear.cpp LinearExample.cpp LinearPiecewise.cpp LinearPiecewiseExample.cpp
    ../../../my-lib/drive/utility/filter/: filter.cpp filterExample.cpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
